<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
	<project>
		<path>$WS_DIR$\Connectivity Test\Connectivity Test.xml</path>
	</project>
<batchBuild/>
</workspace>
