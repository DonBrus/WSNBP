<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
	<project>
		<path>$WS_DIR$\Repeater\Repeater.xml</path>
	</project>
<batchBuild/>
</workspace>
